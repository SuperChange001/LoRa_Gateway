# Keil uVision project LoRa_Gateway.uvproj, settings and files
target LoRa_Gateway (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LoRa_Gateway +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\GPS;..\HARDWARE\DELAY;..\HARDWARE\USART1;..\HARDWARE\USART2;..\HARDWARE\USART3;..\HARDWARE\FLASH;..\HARDWARE\TIMER;..\HARDWARE\RTC;..\HARDWARE\FATS;..\HARDWARE\FATS\option;..\HARDWARE\KEY;..\HARDWARE\LED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/DELAY/: delay.c
    ../HARDWARE/USART1/: usart1.c
    ../HARDWARE/TIMER/: Timer.c
    ../HARDWARE/RTC/: Calendar.c nongli.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_exti.c
